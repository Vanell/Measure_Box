# Repository Vanell/Measure_Box

File README.md:

# Measure_Box
My plastic box with a lot of thing in

#List of thing in

- GPS
- LCD screen
- Humidity/Temperature
- Pressure/Temperature
- Accelorometer
- ESP-01

## KiCad design kicad/elecboitier.kicad_pcb

Parts:
4.7K1, 4.7K2: R
GPS1: VK2828U7G5LF
LCD2: LCD_12864-SAINSMART
S1: MPU-6050
S3: GY-63
SH1: ARDUINO_NANO
TH1: DHT22_TEMPERATURE_HUMIDITY
U1: MICRO-B_USB
WIFI1: ADAPTATER_ESP01

Connections:
+5V: 4.7K1.2, 4.7K2.2, GPS1.5 (VCC), LCD2.10 (VCC), S1.1 (VCC), S3.1 (VCC), SH1.VIN, TH1.1, WIFI1.3 (VCC)
/BTN_EN1: LCD2.15 (BNT_EN1), SH1.2
/BTN_EN2: LCD2.13 (BTN_EN2), SH1.3 (3_(*))
/BTN_ENC: LCD2.2 (BTN_ENC), SH1.4
/BTN_STOP: LCD2.18 (BTN_STOP), SH1.A2
/Beeper: LCD2.1 (Beeper), SH1.10 (10_(SS/*))
/DHT22_DATA: SH1.5 (5_(*)), TH1.2
/LCD_SLAVE: LCD2.4 (LCD_CS), SH1.A0
/MISO: LCD2.11 (MISO_SD), SH1.11 (11_(MISO/*))
/MOSI: LCD2.3 (LCD_MOSI), LCD2.16 (SD_MOSI), SH1.12 (12_(MOSI))
/RX_ESP01: SH1.9 (9_(*)), WIFI1.1 (RX)
/RX_GPS: GPS1.3 (RX), SH1.7
/RX_PC: SH1.1 (TX), U1.2 (D-)
/SCK: LCD2.5 (LCD_SCLK), LCD2.12 (SD_SCK), SH1.13 (13_(SCK))
/SCL: 4.7K1.1, S1.3 (SCL), S3.3 (SCLK), SH1.A5
/SDA: 4.7K2.1, S1.4 (SDA), S3.4 (MOSI/SDA), SH1.A4
/SD_SLAVE: LCD2.14 (SD_CS), SH1.A1
/TX_ESP01: SH1.8, WIFI1.2 (TX)
/TX_GPS: GPS1.4 (TX), SH1.6 (6_(*))
/TX_PC: SH1.0 (RX), U1.3 (D+)
GND: GPS1.2 (GND), LCD2.9 (GND), LCD2.19 (GND), S1.2 (GND), S3.2 (GND), SH1.GND1 (GND/1), TH1.4, U1.5 (GND), WIFI1.4 (GND)

Board: 2 copper layers, 83.8 x 76.2 mm, 10 parts (1 on the bottom side), 21 nets.

## Commit log

2016-06-26 Create my readme
2016-06-26 add kicad file and begin prog
